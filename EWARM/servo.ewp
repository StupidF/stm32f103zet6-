# IAR project servo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD
  ICCARM.CCIncludePath2: ..\CMSIS\CMSIS\DeviceSupport; ..\CMSIS\STM32F10x_StdPeriph_Driver\inc; ..\USER; ..\HARDWARE\ADC; ..\HARDWARE\LED; ..\HARDWARE\SERVO; ..\HARDWARE\OLED; ..\HARDWARE\TIMER; ..\SYSTEM\delay; ..\SYSTEM\sys; ..\SYSTEM\usart
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: servo.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../CMSIS/CMSIS/DeviceSupport/startup/: startup_stm32f10x_md.s
    ../CMSIS/CMSIS/DeviceSupport/: system_stm32f10x.c
  group FWLIB
    ../CMSIS/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/SERVO/: servo.c
    ../HARDWARE/TIMER/: timer.c
  group NOTE
    ../NOTE/: note.txt
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group USER
    ../USER/: stm32f10x_it.c test.c
